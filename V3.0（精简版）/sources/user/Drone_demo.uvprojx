# Keil uVision project Drone_demo.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Drone_demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1,__FPU_USED=1,__CC_ARM
  c include: ..\user;..\STM32F4xx_StdPeriph_Driver\CORE;..\STM32F4xx_StdPeriph_Driver\FWLIB\inc;..\other;..\communicate;..\drv;..\dev;..\math;..\IMU;..\control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c allcontrol.c
  group dev
    ../dev/: AT24C02.c led.c mpu6050.c remote.c motor.c AK8975.c spl06.c GPS.c
  group drv
    ../drv/: I2C_soft.c TIM.c ppm.c usart.c DMA.c
  group math
    ../math/: arm_cortexM4lf_math.lib LeastSquare.c
  group other
    ../other/: delay.c
  group communicate
    ../communicate/: ANO_DT.c
  group FWLIB
    ../STM32F4xx_StdPeriph_Driver/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../STM32F4xx_StdPeriph_Driver/CORE/: startup_stm32f40_41xxx.s
  group control
    ../control/: pid.c
  group IMU
    ../IMU/: DirectIMU.c Altitude.c
